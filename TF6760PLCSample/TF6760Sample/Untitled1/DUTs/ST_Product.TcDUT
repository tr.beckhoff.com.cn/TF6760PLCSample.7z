TYPE ST_Product :
STRUCT
	Id:DINT;
	CreatDateTime:DATE_AND_TIME;
	BarCode:STRING;
	FinalPressure:LREAL;
	FinalDisplacement:LREAL;
	IsQualified:BOOL;
END_STRUCT
END_TYPE
