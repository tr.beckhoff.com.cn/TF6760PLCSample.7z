TYPE ST_PagedResult :
STRUCT
	CurrentPage:INT;
	PageSize:INT;
END_STRUCT
END_TYPE
